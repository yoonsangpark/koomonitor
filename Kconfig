## Kconfig
```kconfig
config KOOMONITOR
	tristate "Koomonitor  Driver"
	help
	  This is koomonitor Driver
```
